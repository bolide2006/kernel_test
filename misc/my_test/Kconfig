## misc/my_test/Kconfig
```kconfig
menu "My test cases"
config MY_TEST
	tristate "My test cases"
	default y
	help
	  Self driver test for debug!
endmenu
```
